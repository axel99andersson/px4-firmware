## src/modules/referencemonitor/Kconfig
```kconfig
menuconfig MODULES_REFERENCEMONITOR
	bool "referenceMonitor"
	default n
	help
		Enable support for referencemonitor
```
